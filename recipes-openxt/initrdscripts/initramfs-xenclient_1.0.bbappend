FILESEXTRAPATHS := "${THISDIR}/${PN}:"

PRINC := "${@int(PRINC) + 100}"

