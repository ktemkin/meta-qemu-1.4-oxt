FILESEXTRAPATHS := "${THISDIR}/files/xenclient-stubdomain:"
